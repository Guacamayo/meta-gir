
GIR_EXTRA_LIBS_PATH = "../gdk/.libs:../gtk/.libs"

inherit g-ir

