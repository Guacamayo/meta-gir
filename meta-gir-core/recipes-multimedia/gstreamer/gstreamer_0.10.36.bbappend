GIR_EXTRA_LIBS_PATH = "../../../gst/.libs"

inherit g-ir
