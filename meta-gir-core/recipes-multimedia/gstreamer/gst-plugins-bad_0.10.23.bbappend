
inherit g-ir

include gst-plugins.inc
