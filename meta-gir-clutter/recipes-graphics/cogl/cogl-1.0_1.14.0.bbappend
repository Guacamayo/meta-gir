
GIR_EXTRA_LIBS_PATH = "../cogl/.libs"

inherit g-ir
