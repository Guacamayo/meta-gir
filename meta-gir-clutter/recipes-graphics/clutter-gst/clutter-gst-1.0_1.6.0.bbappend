
inherit g-ir
